# Keil uVision project 19.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 19 +hex
  c flags: Optimize=9
  group scMain
    ./: 19.c
    ./common/: timeget.c
  group Lcd12864Ctrl
    ./common/: lcd12864.c lcd12864_draw.c
  group App_Battle
    ./mainfile/: app_battle.c app_battle_bomb.c app_battle_car.c app_battle_stream.c app_battle_unit.c app_battle_map.c app_battle_aictrl.c app_battle_ui.c
